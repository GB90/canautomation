# IAR project USBLEDStrip.ewp, settings and files
configuration Default (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103x4 ST STM32F103x4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_LD
  ICCARM.CCIncludePath2: ..\inc; ..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\Libraries\STM32_USB-FS-Device_Driver\inc; ..\..\Libraries\STM32F10x_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM3210E-EVAL_VirtualComport_Loopback.bin
  ILINK.IlinkOutputFile: VirtualComport_Loopback.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group STM32F10x/CMSIS
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_ld.s
    ../src/: system_stm32f10x.c
  group STM32F10x/STM32F10x_StdPeriph_Driver
    ../src/: can.c
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_can.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group USB-FS-Device_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_spi.c
    ../../Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group User
    ../src/: bespeckle.c hw_config.c led_strip_driver.c main.c stm32_it.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
